## boards/shields/palette/Kconfig.defconfig
```kconfig
if SHIELD_PALETTE_KEYBOARD

config ZMK_KEYBOARD_NAME
    default "PaletteBoard"

endif
```
